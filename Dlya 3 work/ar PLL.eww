<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>F:\09112019\2.ewp</path>
    </project>
    <batchBuild />
</workspace>
